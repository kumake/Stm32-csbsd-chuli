# Keil uVision project SRAM.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SRAM +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\DMA;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\TOUCH;..\HARDWARE\SRAM;..\HARDWARE\SIM900A;..\emWIN_GUI\inc;..\emWIN_GUI\Config;..\HARDWARE\TIMER3;..\HARDWARE\TOUCH;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\DEMO;..\MALLOC;..\FATFS;..\HARDWARE\SDIO;..\HARDWARE\BEEP;..\FONT;..\GUIAPP;..\GUI_DEMO;..\FIFO;..\HARDWARE\USART2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/SIM900A/: sim900a.c
    ../HARDWARE/TIMER3/: timer3.c
    ../HARDWARE/TOUCH/: touch.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/USART2/: usart2.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c xdelay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_exti.c
  group emWIN_GUI
    ../emWIN_GUI/Config/: GUIConf.c LCDConf_FlexColor_Template.c
    ../emWIN_GUI/Lib/: STemWin522_CM3_Keil.lib
    ../emWIN_GUI/OS/: GUI_X.c GUI_X_Touch_Analog.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/: ff.c diskio.c
    ../FATFS/option/: mycc936.c
  group FONT
    ../FONT/: ftfile.c font_change.c
  group GUIAPP
    ../GUIAPP/: GUIAPP_Main.c GUIAPP_DEMO.c GUIAPP_MEASURE.c GUIAPP_DISPLAY.c
  group FIFO
    ../FIFO/: fifo.c
